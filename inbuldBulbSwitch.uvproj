# Keil uVision project inbuldBulbSwitch.uvproj, settings and files
target TM4C123GH6PMI (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: inbuldBulbSwitch
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./: startup_TM4C123.s
    C:/Keil/ARM/Startup/TI/TM4C123/: system_TM4C123.c
  group Source
    ./: main.c
